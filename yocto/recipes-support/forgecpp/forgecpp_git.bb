SUMMARY = "forgecpp - batteries-included C++17 framework for Linux daemons"
DESCRIPTION = "spdlog, CLI11, replxx, BS::thread_pool, moodycamel::ConcurrentQueue, \
nlohmann/json, toml++, cpp-httplib and doctest, bundled and glued together into \
a small application framework."
HOMEPAGE = "https://github.com/dogukanarat/forgecpp"
SECTION = "libs"
# forgecpp (MIT) + bundled: spdlog, nlohmann/json, toml++, cpp-httplib, doctest,
# BS::thread_pool (MIT), CLI11 (BSD-3-Clause), replxx (BSD-3-Clause),
# moodycamel::ConcurrentQueue (BSD-2-Clause or BSL-1.0).
LICENSE = "MIT & BSD-3-Clause & BSD-2-Clause"
LIC_FILES_CHKSUM = " \
    file://LICENSE;md5=d651bd6255f4ea85c3b1b170b8dd19c6 \
    file://third_party/CLI11/LICENSE;md5=744e78b25a90f01b35b087d9fb985ed4 \
"

SRC_URI = "gitsm://github.com/dogukanarat/forgecpp.git;protocol=https;branch=master"
# Pin a release commit for reproducible builds.
SRCREV ?= "${AUTOREV}"
PV = "0.2.0+git${SRCPV}"

S = "${WORKDIR}/git"

DEPENDS = "openssl zlib"

inherit cmake pkgconfig

# install.sh builds the bundled libraries and forgecpp with the toolchain file
# generated by cmake.bbclass and stages everything into ${D}.
FORGECPP_INSTALL_ARGS ?= ""

do_configure() {
    :
}

do_compile() {
    ${S}/install.sh \
        --toolchain ${WORKDIR}/toolchain.cmake \
        --prefix ${prefix} \
        --libdir ${baselib} \
        --destdir ${B}/stage \
        --build-dir ${B} \
        --build-type Release \
        --jobs ${@oe.utils.cpu_count()} \
        --no-rpath \
        --no-sudo \
        --quiet \
        ${FORGECPP_INSTALL_ARGS}
}

do_install() {
    install -d ${D}
    cp -R --no-dereference --preserve=mode,links ${B}/stage/. ${D}/
}

# Headers, CMake packages, pkg-config files and the static test helper are
# development files; libforgecpp, libspdlog and libreplxx are runtime.
PACKAGES =+ "${PN}-tools"
FILES:${PN}-tools = "${bindir}/forgecpp-new"
RDEPENDS:${PN}-tools = "bash"
FILES:${PN}-dev += "${datadir}/cmake ${libdir}/cmake ${datadir}/pkgconfig ${datadir}/licenses"
FILES:${PN}-staticdev += "${libdir}/libforgecpp_testing.a"
